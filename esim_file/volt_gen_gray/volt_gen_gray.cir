* R:\esim_simulations\volt_gen_gray\volt_gen_gray.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 23:43:58

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  clk Net-_U2-Pad8_ Net-_U5-Pad3_ gray_bin_5bit_fsm
U6  Net-_U5-Pad3_ clk out4 out3 out2 out1 out0 sipo_5bit
vin1  in0 GND pulse
vin2  in1 GND pulse
vin3  in2 GND pulse
vin4  in3 GND pulse
vin5  in4 GND pulse
vclk1  Net-_U4-Pad6_ GND pulse
vshift1  shift GND pulse
U12  out4 plot_v1
U14  out3 plot_v1
U15  out2 plot_v1
U16  out1 plot_v1
U17  out0 plot_v1
U7  in0 plot_v1
U3  clk plot_v1
U9  in1 plot_v1
U10  in2 plot_v1
U11  in3 plot_v1
U13  in4 plot_v1
U4  in4 in3 in2 in1 in0 Net-_U4-Pad6_ shift Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ clk Net-_U2-Pad7_ adc_bridge_7
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ clk Net-_U2-Pad7_ Net-_U2-Pad8_ piso_5bit
U1  shift plot_v1
scmode1  SKY130mode
X1  vdd vss GND Net-_SC1-Pad1_ analog GND avsd_opamp
SC5  Net-_SC1-Pad1_ Net-_SC5-Pad2_ GND sky130_fd_pr__res_generic_pd
SC4  Net-_SC1-Pad1_ Net-_SC4-Pad2_ GND sky130_fd_pr__res_generic_pd
SC3  Net-_SC1-Pad1_ Net-_SC3-Pad2_ GND sky130_fd_pr__res_generic_pd
SC2  Net-_SC1-Pad1_ Net-_SC2-Pad2_ GND sky130_fd_pr__res_generic_pd
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ GND sky130_fd_pr__res_generic_pd
U8  analog plot_v1
v1  vdd GND DC
v2  GND vss DC
U18  out0 out1 out2 out3 out4 Net-_SC5-Pad2_ Net-_SC4-Pad2_ Net-_SC3-Pad2_ Net-_SC2-Pad2_ Net-_SC1-Pad2_ dac_bridge_5

.end
